Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2020-06-24T14:24:45
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 24 14:24:45 2020 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{1341CA9F-8F8E-417A-B51A-1CA65AA77039}\ifc * Database version: 5507 * Database creation date: Wed Jun 24 14:24:44 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 24 14:24:44 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 24 14:24:44 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Panton, Furniture_Chairs_Vitra_Panton_Chair:Panton:330523
In: Level 1
Type - Material: 04 white
Type - General(Type) - Author: Convergo AB; BIMObjectName: Furniture_Chairs_Vitra_Panton_Chair; ConvergoRefNr: 0089-2006-0023-CH; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: Conceived by Verner Panton in 1960, the Panton chair was developed for serial production in collaboration with Vitra (1967). Today, the all-plastic chair is an icon of twentieth-century design. It has received numerous international design awards and is present in the collections of many prominent museums. It is available in a choice of bold and subdued colours.; Revision: n/a; Uniclass2: Pr_40_50_12_48; Uniclass2015Description: Easy chairs; Uniclass2015Reference: Pr_40_50_12_48; Version: 1; VersionDate: 22/06/2020
Type - Identity Data(Type) - Collection: Panton; Cost: 0; Description: Conceived by Verner Panton in 1960, the Panton chair was developed for serial production in collaboration with Vitra (1967). Today, the all-plastic chair is an icon of twentieth-century design. It has received numerous international design awards and is present in the collections of many prominent museums. It is available in a choice of bold and subdued colours.; Designer: Verner Panton; Manufacturer: Vitra; Model: Panton; OmniClass Number: 23.40.20.14.14.14; OmniClass Title: Settees, Sofas; ProductDatasheet: https://www.vitra.com/en-un/_storage/asset/177940/storage/master/download/FS_Panton_Chair-EN_Preview-Single-Page.pdf; Type Name: Panton; URL: https://www.vitra.com/en-un/living/product/details/panton-chair
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; Category: Chairs; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Furniture_Chairs_Vitra_Panton_Chair; Features: Suited for outdoor use. 100% recyclable.; Finish: Material: dyed-through polypropylene. Matt finish. Note: special additives retard the fading of colours due to UV radiation. However, if the chair is exposed to sunlight for prolonged periods, the colour may change over time. We recommend limited exposure to sunlight.; Grade: n/a; Material: Polypropylene; ModelNumber: n/a; ModelReference: n/a; Name: Vitra_Panton_Chair; ReplacementCost: n/a; Shape: Sculptured; Size: 500x610x830 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 1.15765 m2; Volume: 0.231318 m3
Materials and Finishes - ChairMainMaterial: 04 white
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: Furniture_Chairs_Vitra_Panton_Chair: Panton; Family and Type: Furniture_Chairs_Vitra_Panton_Chair: Panton; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Furniture_Chairs_Vitra_Panton_Chair: Panton; Type Id: Furniture_Chairs_Vitra_Panton_Chair: Panton; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
